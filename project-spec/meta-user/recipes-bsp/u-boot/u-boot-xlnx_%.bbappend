FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://platform-top.h \
            file://user_2019-12-05-14-27-00.cfg \
            "

SRC_URI += "file://0001-zynq-MAC-in-flash-OTP.patch "
